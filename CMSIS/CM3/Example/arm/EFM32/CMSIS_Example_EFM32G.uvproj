# Keil uVision project CMSIS_Example_EFM32G.uvproj, settings and files
target EFM32 Blink (ARM-ADS)
  device: EFM32G890F128 Energymicro
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: EFM32_Blink
  c flags: Optim=1
  c define: EFM32G890F128
  c include: ..\..\..\s001\emlib\CMSIS\Core\CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group SourceFiles
    ./: main_efm32.c dvkreg.c
  group CMSIS
    ../../../DeviceSupport/EnergyMicro/EFM32/startup/arm/: startup_efm32.s
    ../../../CoreSupport/: core_cm3.c
    ../../../DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
  group Information
    ./: Abstract.txt
